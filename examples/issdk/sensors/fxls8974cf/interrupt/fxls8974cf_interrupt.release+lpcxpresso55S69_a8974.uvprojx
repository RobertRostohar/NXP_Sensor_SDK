# Keil uVision project fxls8974cf_interrupt.release+lpcxpresso55S69_a8974.uvprojx, settings and files
target release+lpcxpresso55S69_a8974 (6180000::V6.18::ARMCLANG)
  device: LPC55S69JBD100:cm33_core0 NXP
  pack: NXP.LPC55S69_DFP.14.0.0
  cpu: IRAM(0x10000000,0x09d800) IRAM2(0x20000000,0x040000) IROM(0x03000000,0x020000) IROM2(0x13000000,0x020000) XRAM(0x20040000,0x4000) XRAM2(0x30040000,0x4000) XRAM3(0x04000000,0x8000) XROM(0x00000000,0x09d800) CPUTYPE("Cortex-M33") FPU3(SFPU) DSP TZ CLOCK(12000000) ELITTLE
  c flags: Optim=1 v6Lang=3
  c define: SERIAL_PORT_TYPE_UART=1 BOARD_HEADER="lpc55s69.h" SHIELD_HEADER="frdm_stbi_a8974_shield.h" CPU_LPC55S69JBD100_cm33_core0 NDEBUG
  c misc: -fno-builtin
  asm define: as above
  asm include: ..\..\..\..\..\boards\lpcxpresso55s69;..\..\..\..\..\middleware\issdk\drivers\gpio;..\..\..\..\..\middleware\issdk\drivers\gpio\lpc;..\..\..\..\..\middleware\issdk\drivers\systick;..\..\..\..\..\middleware\issdk\hal;..\..\..\..\..\middleware\issdk\sensors;..\..\..\..\..\shields\a8974
  memory RVCT1: RAM 0x0 size 0x9d800
  memory RVCT4: RAM 0x3000000 size 0x20000
  memory RVCT5: RAM 0x13000000 size 0x20000
  memory RVCT6: ROM 0x20040000 size 0x4000
  memory RVCT7: ROM 0x30040000 size 0x4000
  memory RVCT8: ROM 0x4000000 size 0x8000
  memory RVCT9: ROM 0x10000000 size 0x9d800
  memory RVCT10: ROM 0x20000000 size 0x40000
  scatter file: ../../../../../boards/lpcxpresso55s69/RTE/Device/LPC55S69_cm33_core0/LPC55S69_cm33_core0_flash.scf
  link misc: --entry=Reset_Handler --info summarysizes --remove --keep=*(.crp) --keep=*(.FlashConfig)
  group source
    ./: fxls8974cf_interrupt.c
  group doc
    ./: readme.txt
  group hal
    ../../../../../middleware/issdk/hal/: issdk_hal.h
  group utilities
    ../../../../../middleware/issdk/drivers/systick/: systick_utils.c systick_utils.h
  group interfaces
    ../../../../../middleware/issdk/sensors/: register_io_i2c.c register_io_spi.c sensor_io_spi.c sensor_io_i2c.c register_io_i2c.h register_io_spi.h sensor_io_spi.h sensor_io_i2c.h sensor_drv.h
  group sensors
    ../../../../../middleware/issdk/sensors/: fxls8974.h fxls8974_drv.h fxls8974_drv.c
  group gpio_driver
    ../../../../../middleware/issdk/drivers/gpio/lpc/: gpio_driver_irq.c gpio_driver.c gpio_driver.h
    ../../../../../middleware/issdk/drivers/gpio/: Driver_GPIO.h
  group board
    ../../../../../boards/lpcxpresso55s69/: lpc55s69.c lpc55s69.h
  group shield
    ../../../../../shields/a8974/: frdm_stbi_a8974_shield.h
software components: CMSIS Driver:I2C:Custom 1.0.0, CMSIS Driver:SPI:Custom 1.0.0, CMSIS Driver:USART:Custom 1.0.0, CMSIS:CORE 5.6.0, Board Support:SDK Project Template:project_template 1.0.0, CMSIS Driver:I2C:flexcomm_i2c_cmsis 2.2.0, CMSIS Driver:SPI:flexcomm_spi_cmsis 2.4.0, CMSIS Driver:USART:flexcomm_usart_cmsis 2.2.0, Device:CMSIS:LPC55S69_system 1.0.0, Device:SDK Drivers:clock 2.3.3, Device:SDK Drivers:common 2.3.1, Device:SDK Drivers:dma 2.4.3, Device:SDK Drivers:flexcomm 2.0.2, Device:SDK Drivers:gint 2.0.3, Device:SDK Drivers:gpio 2.1.7, Device:SDK Drivers:i2c 2.3.0, Device:SDK Drivers:i2c_dma 2.3.0, Device:SDK Drivers:inputmux 2.0.4, Device:SDK Drivers:inputmux_connections 2.0.1, Device:SDK Drivers:iocon 2.2.0, Device:SDK Drivers:lists 1.0.0, Device:SDK Drivers:power 2.3.0, Device:SDK Drivers:reset 2.1.2, Device:SDK Drivers:spi 2.2.1, Device:SDK Drivers:spi_dma 2.1.1, Device:SDK Drivers:usart 2.6.0, Device:SDK Drivers:usart_adapter 1.0.0, Device:SDK Drivers:usart_dma 2.6.0, Device:SDK Project Template:RTE_Device 1.0.0, Device:SDK Utilities:assert 1.0.0, Device:SDK Utilities:debug_console 1.0.0, Device:SDK Utilities:serial_manager 1.0.1, Device:SDK Utilities:serial_manager_uart 1.0.0, Device:Startup 1.1.0

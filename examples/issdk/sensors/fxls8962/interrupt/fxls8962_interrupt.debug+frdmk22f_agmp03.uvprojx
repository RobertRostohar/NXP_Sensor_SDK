# Keil uVision project fxls8962_interrupt.debug+frdmk22f_agmp03.uvprojx, settings and files
target debug+frdmk22f_agmp03 (6180000::V6.18::ARMCLANG)
  device: MK22FN512VLH12 NXP
  pack: NXP.MK22F51212_DFP.15.0.0
  cpu: IRAM(0x1fff0000,0x010000) IRAM2(0x20000000,0x010000) IROM(0x00000000,0x080000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  c flags: Optim=1 v6Lang=3
  c define: MCUXPRESSO_SDK PRINTF_ADVANCED_ENABLE SERIAL_PORT_TYPE_UART=1 BOARD_HEADER="frdm_k22f.h" SHIELD_HEADER="frdm_stbc_agmp03_shield.h" CPU_MK22FN512VLH12 FRDM_K22F FREEDOM DEBUG
  c misc: -fno-builtin
  asm define: as above
  asm include: ..\..\..\..\..\boards\frdmk22f;..\..\..\..\..\middleware\issdk\drivers\gpio;..\..\..\..\..\middleware\issdk\drivers\gpio\kinetis;..\..\..\..\..\middleware\issdk\drivers\systick;..\..\..\..\..\middleware\issdk\hal;..\..\..\..\..\middleware\issdk\sensors;..\..\..\..\..\shields\agmp03
  memory RVCT4: RAM 0x0 size 0x80000
  memory RVCT9: ROM 0x1fff0000 size 0x10000
  memory RVCT10: ROM 0x20000000 size 0x10000
  scatter file: ../../../../../boards/frdmk22f/RTE/Device/MK22FN512VLH12/MK22FN512xxx12_flash.scf
  link misc: --entry=Reset_Handler --info summarysizes --remove --keep=*(.crp) --keep=*(.FlashConfig)
  group source
    ./: fxls8962_interrupt.c
  group doc
    ./: readme.txt
  group hal
    ../../../../../middleware/issdk/hal/: issdk_hal.h
  group utilities
    ../../../../../middleware/issdk/drivers/systick/: systick_utils.c systick_utils.h
  group interfaces
    ../../../../../middleware/issdk/sensors/: register_io_i2c.c register_io_spi.c sensor_io_spi.c sensor_io_i2c.c register_io_i2c.h register_io_spi.h sensor_io_spi.h sensor_io_i2c.h sensor_drv.h
  group sensors
    ../../../../../middleware/issdk/sensors/: fxls8962.h fxls8962_drv.h fxls8962_drv.c
  group gpio_driver
    ../../../../../middleware/issdk/drivers/gpio/kinetis/: gpio_driver_irq.c gpio_driver.c gpio_driver.h
    ../../../../../middleware/issdk/drivers/gpio/: Driver_GPIO.h
  group board
    ../../../../../boards/frdmk22f/: frdm_k22f.c frdm_k22f.h
  group shield
    ../../../../../shields/agmp03/: frdm_stbc_agmp03_shield.h
software components: CMSIS Driver:I2C:Custom 1.0.0, CMSIS Driver:SPI:Custom 1.0.0, CMSIS Driver:USART:Custom 1.0.0, CMSIS:CORE 5.6.0, Board Support:SDK Project Template:project_template 1.0.0, CMSIS Driver:I2C:i2c_cmsis 2.2.0, CMSIS Driver:SPI:dspi_cmsis 2.3.0, CMSIS Driver:USART:uart_cmsis 2.1.0, Device:CMSIS:MK22F51212_header 1.0.0, Device:CMSIS:MK22F51212_system 1.0.0, Device:SDK Drivers:adc 2.3.0, Device:SDK Drivers:clock 2.3.0, Device:SDK Drivers:common 2.3.2, Device:SDK Drivers:dmamux 2.0.5, Device:SDK Drivers:dspi 2.2.4, Device:SDK Drivers:dspi_edma 2.2.4, Device:SDK Drivers:edma 2.4.3, Device:SDK Drivers:flash 3.0.0, Device:SDK Drivers:gpio 2.6.0, Device:SDK Drivers:i2c 2.0.9, Device:SDK Drivers:i2c_edma 2.0.9, Device:SDK Drivers:lists 1.0.0, Device:SDK Drivers:lptmr 2.1.1, Device:SDK Drivers:lpuart 2.5.3, Device:SDK Drivers:port 2.3.0, Device:SDK Drivers:rtc 2.2.1, Device:SDK Drivers:smc 2.0.7, Device:SDK Drivers:uart 2.5.1, Device:SDK Drivers:uart_adapter 1.0.0, Device:SDK Drivers:uart_edma 2.5.3, Device:SDK Project Template:RTE_Device 1.0.0, Device:SDK Utilities:assert 1.0.0, Device:SDK Utilities:debug_console 1.0.1, Device:SDK Utilities:serial_manager 1.0.1, Device:SDK Utilities:serial_manager_uart 1.0.0, Device:Startup 1.1.0

# IAR project flexram_ram_allocate.ewp, settings and files
configuration flexspi_nor_sdram_debug (ARM, debug)
  General.OGChipSelectEditMenu: MIMXRT1062xxx6A NXP MIMXRT1062xxx6A
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 41
  General.FPU2: 7
  ICCARM.CCDefines: DEBUG; XIP_EXTERNAL_FLASH=1; XIP_BOOT_HEADER_ENABLE=1; XIP_BOOT_HEADER_DCD_ENABLE=1; SKIP_SYSCLK_INIT; DATA_SECTION_IS_CACHEABLE=1; CPU_MIMXRT1062DVL6A; MCUXPRESSO_SDK
  ICCARM.CCDiagSuppress: Pa082,Pa050
  ICCARM.CCIncludePath2: ..
  ICCARM.CCOptLevel: 2
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.ADefines: DEBUG; __STARTUP_INITIALIZE_NONCACHEDATA
  ILINK.IlinkOutputFile: flexram_ram_allocate.out
  ILINK.IlinkIcfFile: MIMXRT1062xxxxx_flexspi_nor_sdram.icf
  ILINK.IlinkProgramEntryLabel: Reset_Handler
configuration sdram_txt_debug (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: SKIP_SYSCLK_INIT; DEBUG; CPU_MIMXRT1062DVL6A; MCUXPRESSO_SDK
  ILINK.IlinkIcfFile: evkmimxrt1060_flexram_ram_allocate.icf
configuration flexspi_nor_sdram_release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: XIP_EXTERNAL_FLASH=1; XIP_BOOT_HEADER_ENABLE=1; XIP_BOOT_HEADER_DCD_ENABLE=1; SKIP_SYSCLK_INIT; DATA_SECTION_IS_CACHEABLE=1; NDEBUG; CPU_MIMXRT1062DVL6A; MCUXPRESSO_SDK
  AARM.ADefines: NDEBUG; __STARTUP_INITIALIZE_NONCACHEDATA
configuration sdram_txt_release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: SKIP_SYSCLK_INIT; NDEBUG; CPU_MIMXRT1062DVL6A; MCUXPRESSO_SDK
  AARM.ADefines: NDEBUG; __STARTUP_INITIALIZE_NONCACHEDATA
  ILINK.IlinkIcfFile: evkmimxrt1060_flexram_ram_allocate.icf
  group source
    ../: flexram.c
  group board
    ../: pin_mux.c pin_mux.h board.c board.h clock_config.c clock_config.h dcd.c dcd.h
  group doc
    ../: readme.md

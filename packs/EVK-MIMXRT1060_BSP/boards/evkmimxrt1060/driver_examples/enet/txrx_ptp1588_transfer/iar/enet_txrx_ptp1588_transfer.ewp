# IAR project enet_txrx_ptp1588_transfer.ewp, settings and files
configuration debug (ARM, debug)
  General.OGChipSelectEditMenu: MIMXRT1062xxx6A NXP MIMXRT1062xxx6A
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 41
  General.FPU2: 7
  ICCARM.CCDefines: DEBUG; ENET_ENHANCEDBUFFERDESCRIPTOR_MODE=1; FSL_FEATURE_PHYKSZ8081_USE_RMII50M_MODE; CPU_MIMXRT1062DVL6A; PRINTF_ADVANCED_ENABLE=1; MCUXPRESSO_SDK
  ICCARM.CCDiagSuppress: Pa082,Pa050
  ICCARM.CCIncludePath2: ..
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.ADefines: DEBUG; __STARTUP_INITIALIZE_NONCACHEDATA
  ILINK.IlinkOutputFile: enet_txrx_ptp1588_transfer.out
  ILINK.IlinkConfigDefines: __stack_size__=0x1000; __heap_size__=0x1000
  ILINK.IlinkIcfFile: MIMXRT1062xxxxx_ram.icf
  ILINK.IlinkProgramEntryLabel: Reset_Handler
configuration flexspi_nor_debug (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: DEBUG; XIP_EXTERNAL_FLASH=1; XIP_BOOT_HEADER_ENABLE=1; ENET_ENHANCEDBUFFERDESCRIPTOR_MODE=1; FSL_FEATURE_PHYKSZ8081_USE_RMII50M_MODE; CPU_MIMXRT1062DVL6A; PRINTF_ADVANCED_ENABLE=1; MCUXPRESSO_SDK
  ICCARM.CCOptLevel: 2
  ILINK.IlinkIcfFile: MIMXRT1062xxxxx_flexspi_nor.icf
configuration sdram_debug (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: FSL_SDK_ENABLE_DRIVER_CACHE_CONTROL=1; SKIP_SYSCLK_INIT; DATA_SECTION_IS_CACHEABLE=1; DEBUG; ENET_ENHANCEDBUFFERDESCRIPTOR_MODE=1; FSL_FEATURE_PHYKSZ8081_USE_RMII50M_MODE; CPU_MIMXRT1062DVL6A; PRINTF_ADVANCED_ENABLE=1; MCUXPRESSO_SDK
  ICCARM.CCOptLevel: 2
  ILINK.IlinkIcfFile: MIMXRT1062xxxxx_sdram.icf
configuration release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG; ENET_ENHANCEDBUFFERDESCRIPTOR_MODE=1; FSL_FEATURE_PHYKSZ8081_USE_RMII50M_MODE; CPU_MIMXRT1062DVL6A; PRINTF_ADVANCED_ENABLE=1; MCUXPRESSO_SDK
  ICCARM.CCOptLevel: 3
  AARM.ADefines: NDEBUG; __STARTUP_INITIALIZE_NONCACHEDATA
configuration flexspi_nor_release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: XIP_EXTERNAL_FLASH=1; XIP_BOOT_HEADER_ENABLE=1; NDEBUG; ENET_ENHANCEDBUFFERDESCRIPTOR_MODE=1; FSL_FEATURE_PHYKSZ8081_USE_RMII50M_MODE; CPU_MIMXRT1062DVL6A; PRINTF_ADVANCED_ENABLE=1; MCUXPRESSO_SDK
  ICCARM.CCOptLevel: 2
  AARM.ADefines: NDEBUG; __STARTUP_INITIALIZE_NONCACHEDATA
  ILINK.IlinkIcfFile: MIMXRT1062xxxxx_flexspi_nor.icf
configuration sdram_release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: FSL_SDK_ENABLE_DRIVER_CACHE_CONTROL=1; NDEBUG; SKIP_SYSCLK_INIT; DATA_SECTION_IS_CACHEABLE=1; ENET_ENHANCEDBUFFERDESCRIPTOR_MODE=1; FSL_FEATURE_PHYKSZ8081_USE_RMII50M_MODE; CPU_MIMXRT1062DVL6A; PRINTF_ADVANCED_ENABLE=1; MCUXPRESSO_SDK
  ICCARM.CCOptLevel: 2
  AARM.ADefines: NDEBUG; __STARTUP_INITIALIZE_NONCACHEDATA
  ILINK.IlinkIcfFile: MIMXRT1062xxxxx_sdram.icf
  group source
    ../: enet_txrx_ptp1588_transfer.c
  group board
    ../: pin_mux.c pin_mux.h board.c board.h clock_config.c clock_config.h dcd.c dcd.h
  group doc
    ../: readme.md

# Keil uVision project ecompass_peripheral.uvprojx, settings and files
target ecompass_peripheral debug (ARM-ADS)
  device: MK22FN512VLH12 NXP
  pack: Keil.Kinetis_K20_DFP.1.1.0
  cpu: CPUTYPE("Cortex-M4") FPU2
  output: ecompass_peripheral.out
  c flags: Optim=2 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: DEBUG, CPU_MK22FN512VLH12, PRINTF_FLOAT_ENABLE=1, PRINTF_ADVANCED_ENABLE=1, SDK_I2C_BASED_COMPONENT_USED=1, FRDM_K22F, FREEDOM, MCUXPRESSO_SDK
  c misc: -fno-common  -fdata-sections  -ffreestanding  -fno-builtin  -mthumb
  c include: ..
  asm define: DEBUG
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  memory RVCT10: RAM 0x1fff0000 size 0x10000
  scatter file: MK22FN512xxx12_flash.scf
  link misc: --remove --keep=*(.FlashConfig) --entry=Reset_Handler --diag_suppress 6314
  group source
    ../: ecompass_peripheral.c
  group board
    ../: pin_mux.c pin_mux.h peripherals.c peripherals.h board.c board.h clock_config.c clock_config.h
  group doc
    ../: readme.md
target ecompass_peripheral release (ARM-ADS)
  device: MK22FN512VLH12 NXP
  pack: Keil.Kinetis_K20_DFP.1.1.0
  cpu: CPUTYPE("Cortex-M4") FPU2
  output: ecompass_peripheral.out
  c flags: Optim=7 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: NDEBUG, CPU_MK22FN512VLH12, PRINTF_FLOAT_ENABLE=1, PRINTF_ADVANCED_ENABLE=1, SDK_I2C_BASED_COMPONENT_USED=1, FRDM_K22F, FREEDOM, MCUXPRESSO_SDK
  c misc: as above
  c include: ..
  asm define: NDEBUG
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  memory RVCT10: RAM 0x1fff0000 size 0x10000
  scatter file: MK22FN512xxx12_flash.scf
  link misc: as above
software components: Device:SDK Utilities:debug_console_lite 1.0.0, Device:SDK Utilities:assert_lite 1.0.0, Device:SDK Drivers:port 2.4.1, Device:SDK Drivers:i2c 2.0.9, Device:SDK Drivers:fxos8700cq 1.0.0, Device:SDK Drivers:gpio 2.7.3, Device:SDK Drivers:clock 2.3.0, Device:SDK Drivers:common 2.4.0, Device:CMSIS:MK22F51212_header 1.0.0, Device:SDK Drivers:uart_adapter 1.0.0, Device:SDK Drivers:uart 2.5.1, Device:SDK Drivers:lists 1.0.0, Device:Startup 1.1.0, Device:SDK Drivers:lpuart 2.7.6, Device:SDK Drivers:smc 2.0.7, Device:SDK Utilities:misc_utilities 1.1.1, CMSIS:CORE 5.5.0, Device:CMSIS:MK22F51212_system 1.0.0

# Keil uVision project secure_gpio_s.uvprojx, settings and files
target secure_gpio_s debug (ARM-ADS)
  device: LPC55S69JBD100:cm33_core0 NXP
  pack: NXP.LPC55S69_DFP.13.0.0
  cpu: IRAM(0x20000000,0x044000) IRAM2(0x04000000,0x8000) IROM(0x00000000,0x098000) XRAM(0x40100000,0x4000) CPUTYPE("Cortex-M33") FPU3(SFPU) DSP TZ CLOCK(12000000) ELITTLE
  output: secure_gpio_s.out
  c flags: Optim=2 v6Lang=3 v6LangP=3 wLevel=3
  c define: DEBUG, CPU_LPC55S69JBD100_cm33_core0, MCUXPRESSO_SDK
  c include: ..;../../../secure_gpio_s
  asm define: CPU_LPC55S69JBD100_cm33_core0, DEBUG, KEIL, DEBUG
  asm misc: -mcmse
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x98000
  memory RVCT6: RAM 0x40100000 size 0x4000
  memory RVCT9: RAM 0x20000000 size 0x44000
  memory RVCT10: RAM 0x4000000 size 0x8000
  scatter file: LPC55S69_cm33_core0_flash_s.scf
  link misc: --remove --entry=Reset_Handler --diag_suppress 6314 --import-cmse-lib-out=".\debug\secure_gpio_s_CMSE_lib.o" --diag_suppress L6848E
  group source
    ../: secure_gpio_s.c
  group board
    ../: pin_mux.c pin_mux.h board.c board.h clock_config.c clock_config.h
  group trustzone
    ../: tzm_config.c tzm_config.h veneer_table.c veneer_table.h tzm_api.c tzm_api.h
  group doc
    ../: readme.md
target secure_gpio_s release (ARM-ADS)
  device: LPC55S69JBD100:cm33_core0 NXP
  pack: NXP.LPC55S69_DFP.13.0.0
  cpu: as above
  output: secure_gpio_s.out
  c flags: Optim=2 v6Lang=3 v6LangP=3 wLevel=3
  c define: NDEBUG, CPU_LPC55S69JBD100_cm33_core0, MCUXPRESSO_SDK
  c include: ..;../../../secure_gpio_s
  asm define: CPU_LPC55S69JBD100_cm33_core0, NDEBUG, KEIL, NDEBUG
  asm misc: -mcmse
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x98000
  memory RVCT6: RAM 0x40100000 size 0x4000
  memory RVCT9: RAM 0x20000000 size 0x44000
  memory RVCT10: RAM 0x4000000 size 0x8000
  scatter file: LPC55S69_cm33_core0_flash_s.scf
  link misc: --remove --entry=Reset_Handler --diag_suppress 6314 --import-cmse-lib-out=".\release\secure_gpio_s_CMSE_lib.o" --diag_suppress L6848E
software components: Device:SDK Utilities:debug_console_lite 1.0.0, Device:SDK Utilities:assert_lite 1.0.0, Device:SDK Drivers:iocon 2.2.0, Device:SDK Drivers:common 2.4.0, Device:SDK Drivers:clock 2.3.3, Device:SDK Drivers:power 2.3.0, Device:SDK Drivers:reset 2.1.2, Device:CMSIS:LPC55S69_header 1.0.0, Device:Startup 1.1.0, Device:SDK Drivers:usart 2.8.3, Device:SDK Drivers:flexcomm 2.0.2, Device:SDK Drivers:gpio 2.1.7, Device:SDK Drivers:usart_adapter 1.0.0, Device:SDK Drivers:lists 1.0.0, Device:SDK Utilities:misc_utilities 1.1.1, CMSIS:CORE 5.5.0, Device:CMSIS:LPC55S69_system 1.0.0

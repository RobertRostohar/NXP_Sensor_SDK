# Keil uVision project secure_faults_ns.uvprojx, settings and files
target secure_faults_ns debug (ARM-ADS)
  device: LPC55S69JBD100:cm33_core0 NXP
  pack: NXP.LPC55S69_DFP.13.0.0
  cpu: CPUTYPE("Cortex-M33") FPU3(SFPU) TZ DSP
  output: secure_faults_ns.out
  c flags: Optim=2 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: DEBUG, CPU_LPC55S69JBD100_cm33_core0, MCUXPRESSO_SDK
  c misc: -fno-common  -fdata-sections  -ffreestanding  -fno-builtin  -mthumb
  c include: ..;../../secure_faults_s;../../../secure_faults_ns
  asm define: CPU_LPC55S69JBD100_cm33_core0, DEBUG, KEIL, DEBUG
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x98000
  memory RVCT6: RAM 0x40100000 size 0x4000
  memory RVCT9: RAM 0x20000000 size 0x44000
  memory RVCT10: RAM 0x4000000 size 0x8000
  scatter file: LPC55S69_cm33_core0_flash_ns.scf
  link misc: ../../secure_faults_s/mdk/debug/secure_faults_s_CMSE_lib.o --remove --entry=Reset_Handler --diag_suppress 6314
  group source
    ../: secure_faults_ns.c
  group board
    ../: pin_mux.c pin_mux.h board.c board.h clock_config.c clock_config.h
  group trustzone
    ../: veneer_table.h
  group doc
    ../: readme.md
target secure_faults_ns release (ARM-ADS)
  device: LPC55S69JBD100:cm33_core0 NXP
  pack: NXP.LPC55S69_DFP.13.0.0
  cpu: CPUTYPE("Cortex-M33") FPU3(SFPU) TZ DSP
  output: secure_faults_ns.out
  c flags: Optim=7 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: NDEBUG, CPU_LPC55S69JBD100_cm33_core0, MCUXPRESSO_SDK
  c misc: as above
  c include: ..;../../secure_faults_s;../../../secure_faults_ns
  asm define: CPU_LPC55S69JBD100_cm33_core0, NDEBUG, KEIL, NDEBUG
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x98000
  memory RVCT6: RAM 0x40100000 size 0x4000
  memory RVCT9: RAM 0x20000000 size 0x44000
  memory RVCT10: RAM 0x4000000 size 0x8000
  scatter file: LPC55S69_cm33_core0_flash_ns.scf
  link misc: ../../secure_faults_s/mdk/release/secure_faults_s_CMSE_lib.o --remove --entry=Reset_Handler --diag_suppress 6314
software components: Device:SDK Utilities:debug_console_lite 1.0.0, Device:SDK Utilities:assert_lite 1.0.0, Device:SDK Drivers:iocon 2.2.0, Device:SDK Drivers:common 2.4.0, Device:SDK Drivers:clock 2.3.3, Device:SDK Drivers:power 2.3.0, Device:SDK Drivers:reset 2.1.2, Device:CMSIS:LPC55S69_header 1.0.0, Device:Startup 1.1.0, Device:SDK Drivers:usart 2.8.3, Device:SDK Drivers:flexcomm 2.0.2, Device:SDK Drivers:gpio 2.1.7, Device:SDK Drivers:usart_adapter 1.0.0, Device:SDK Drivers:lists 1.0.0, Device:SDK Utilities:misc_utilities 1.1.1, CMSIS:CORE 5.5.0, Device:CMSIS:LPC55S69_system 1.0.0

# Keil uVision project mailbox_interrupt_cm0plus.uvprojx, settings and files
target mailbox_interrupt_cm0plus debug (ARM-ADS)
  device: LPC54114J256BD64:cm0plus NXP
  pack: Keil.LPC54000_DFP.2.0.0
  cpu: CPUTYPE("Cortex-M0+")
  output: mailbox_interrupt_cm0plus.out
  AfterMake: $K\ARM\ARMCC\bin\fromelf.exe --bincombined --bincombined_base=0x20010000 --output=$Lcore1_image.bin !L
  c flags: Optim=2 OneElfS=1 v6Lang=3 wLevel=3
  c define: DEBUG, CPU_LPC54114J256BD64_cm0plus
  c misc: -fno-common  -fdata-sections  -ffreestanding  -fno-builtin  -mthumb
  c include: .;
  asm define: CPU_LPC54114J256_M0, DEBUG, KEIL, DEBUG, SLAVEBOOT, NO_CRP
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x20020000 size 0x8000
  scatter file: LPC54114J256_cm0plus.scf
  link misc: --remove
  group source
    ./: mailbox_interrupt_core1.c
  group board
    ./: pin_mux.c pin_mux.h board.c board.h clock_config.c clock_config.h
  group doc
    ./: readme.txt
target mailbox_interrupt_cm0plus release (ARM-ADS)
  device: LPC54114J256BD64:cm0plus NXP
  pack: Keil.LPC54000_DFP.2.0.0
  cpu: CPUTYPE("Cortex-M0+")
  output: mailbox_interrupt_cm0plus.out
  AfterMake: as above
  c flags: Optim=7 OneElfS=1 v6Lang=3 wLevel=3
  c define: NDEBUG, CPU_LPC54114J256BD64_cm0plus
  c misc: as above
  c include: .;
  asm define: CPU_LPC54114J256_M0, NDEBUG, KEIL, NDEBUG, SLAVEBOOT, NO_CRP
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x20020000 size 0x8000
  scatter file: LPC54114J256_cm0plus.scf
  link misc: --remove
software components: Device:SDK Utilities:debug_console_lite 1.0.0, Device:SDK Utilities:assert_lite 1.0.0, Device:SDK Drivers:mailbox 2.0.0, Device:SDK Drivers:common 2.2.9, Device:SDK Drivers:clock 2.2.0, Device:SDK Drivers:power 2.0.0, Device:SDK Drivers:iocon 2.1.2, Device:SDK Drivers:gpio 2.1.7, Device:SDK Drivers:inputmux 2.0.3, Device:CMSIS:LPC54114_header 1.0.0, CMSIS:CORE 5.3.0, Device:Startup 1.1.0, Device:SDK Drivers:usart 2.4.0, Device:SDK Drivers:flexcomm 2.0.2, Device:SDK Drivers:usart_adapter 1.0.0, Device:SDK Drivers:lists 1.0.0, Device:SDK Drivers:reset 2.0.1, Device:SDK Drivers:inputmux_connections 2.0.1, CMSIS:DSP 1.7.0, Device:CMSIS:LPC54114_system 1.0.0

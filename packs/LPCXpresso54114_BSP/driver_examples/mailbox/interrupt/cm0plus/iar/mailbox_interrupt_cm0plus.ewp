# IAR project mailbox_interrupt_cm0plus.ewp, settings and files
configuration debug (ARM, debug)
  General.OGChipSelectEditMenu: LPC54114J256_M0+ NXP LPC54114J256_M0+
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 35
  General.FPU2: 0
  ICCARM.CCDefines: DEBUG; CPU_LPC54114J256BD64_cm0plus
  ICCARM.CCDiagSuppress: Pa082,Pa050
  ICCARM.CCIncludePath2: $PROJ_DIR$
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.ADefines: DEBUG; SLAVEBOOT; NO_CRP
  ILINK.IlinkOutputFile: mailbox_interrupt_cm0plus.out
  ILINK.IlinkIcfFile: LPC54114J256_cm0plus.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG; CPU_LPC54114J256BD64_cm0plus
  ICCARM.CCOptLevel: 3
  AARM.ADefines: NDEBUG; SLAVEBOOT; NO_CRP
  group source
    ./: mailbox_interrupt_core1.c
  group board
    ./: pin_mux.c pin_mux.h board.c board.h clock_config.c clock_config.h
  group doc
    ./: readme.txt

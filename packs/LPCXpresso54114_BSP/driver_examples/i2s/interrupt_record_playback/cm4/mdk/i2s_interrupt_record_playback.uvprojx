# Keil uVision project i2s_interrupt_record_playback.uvprojx, settings and files
target i2s_interrupt_record_playback debug (ARM-ADS)
  device: LPC54114J256BD64:cm4 NXP
  pack: Keil.LPC54000_DFP.1.2.0
  cpu: CPUTYPE("Cortex-M4") FPU2
  output: i2s_interrupt_record_playback.out
  c flags: Optim=2 OneElfS=1 v6Lang=3 wLevel=3
  c define: DEBUG, CPU_LPC54114J256BD64_cm4, SDK_I2C_BASED_COMPONENT_USED=1, BOARD_USE_CODEC=1, CODEC_WM8904_ENABLE
  c misc: -fno-common  -fdata-sections  -ffreestanding  -fno-builtin  -mthumb
  c include: .;cm4
  asm define: CPU_LPC54114J256_M4, DEBUG, KEIL, DEBUG
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x20020000 size 0x8000
  scatter file: LPC54114J256_cm4.scf
  link misc: --remove --keep=*(.crp)
  group source
    ./: i2s_interrupt_record_playback.c
    cm4/: music.h
  group board
    cm4/: pin_mux.c pin_mux.h
    ./: board.c board.h clock_config.c clock_config.h
  group doc
    ./: readme.txt
target i2s_interrupt_record_playback release (ARM-ADS)
  device: LPC54114J256BD64:cm4 NXP
  pack: Keil.LPC54000_DFP.1.2.0
  cpu: CPUTYPE("Cortex-M4") FPU2
  output: i2s_interrupt_record_playback.out
  c flags: Optim=7 OneElfS=1 v6Lang=3 wLevel=3
  c define: NDEBUG, CPU_LPC54114J256BD64_cm4, SDK_I2C_BASED_COMPONENT_USED=1, BOARD_USE_CODEC=1, CODEC_WM8904_ENABLE
  c misc: as above
  c include: .;cm4
  asm define: CPU_LPC54114J256_M4, NDEBUG, KEIL, NDEBUG
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x20020000 size 0x8000
  scatter file: LPC54114J256_cm4.scf
  link misc: --remove --keep=*(.crp)
software components: Device:SDK Drivers:codec_i2c 2.1.0, Device:SDK Drivers:common 2.2.9, Device:SDK Drivers:flexcomm_i2c_adapter 1.0.0, Device:SDK Utilities:debug_console_lite 1.0.0, Device:SDK Utilities:assert_lite 1.0.0, Device:SDK Drivers:iocon 2.1.2, Device:SDK Drivers:i2c 2.1.0, Device:SDK Drivers:flexcomm_i2s 2.2.2, Device:SDK Drivers:flexcomm_i2s_dma 2.2.2, Device:SDK Drivers:dma 2.4.2, Device:SDK Drivers:usart 2.4.0, Device:SDK Drivers:wm8904 2.4.3, Device:SDK Drivers:codec 2.2.1, Device:SDK Drivers:wm8904_adapter 2.2.0, Device:SDK Drivers:clock 2.2.0, Device:SDK Drivers:power 2.0.0, Device:SDK Drivers:gpio 2.1.7, Device:SDK Drivers:inputmux 2.0.3, Device:CMSIS:LPC54114_header 1.0.0, CMSIS:CORE 5.3.0, Device:Startup 1.1.0, Device:SDK Drivers:flexcomm 2.0.2, Device:SDK Drivers:usart_adapter 1.0.0, Device:SDK Drivers:lists 1.0.0, Device:SDK Drivers:reset 2.0.1, Device:SDK Drivers:inputmux_connections 2.0.1, CMSIS:DSP 1.7.0, Device:CMSIS:LPC54114_system 1.0.0

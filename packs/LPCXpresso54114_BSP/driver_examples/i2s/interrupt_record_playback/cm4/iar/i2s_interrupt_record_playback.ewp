# IAR project i2s_interrupt_record_playback.ewp, settings and files
configuration debug (ARM, debug)
  General.OGChipSelectEditMenu: LPC54114J256_M4 NXP LPC54114J256_M4
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: DEBUG; CPU_LPC54114J256BD64_cm4; SDK_I2C_BASED_COMPONENT_USED=1; BOARD_USE_CODEC=1; CODEC_WM8904_ENABLE
  ICCARM.CCDiagSuppress: Pa082,Pa050
  ICCARM.CCIncludePath2: $PROJ_DIR$; cm4
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.ADefines: DEBUG
  ILINK.IlinkOutputFile: i2s_interrupt_record_playback.out
  ILINK.IlinkIcfFile: LPC54114J256_cm4.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG; CPU_LPC54114J256BD64_cm4; SDK_I2C_BASED_COMPONENT_USED=1; BOARD_USE_CODEC=1; CODEC_WM8904_ENABLE
  ICCARM.CCOptLevel: 3
  AARM.ADefines: NDEBUG
  group source
    ./: i2s_interrupt_record_playback.c
    cm4/: music.h
  group board
    cm4/: pin_mux.c pin_mux.h
    ./: board.c board.h clock_config.c clock_config.h
  group doc
    ./: readme.txt

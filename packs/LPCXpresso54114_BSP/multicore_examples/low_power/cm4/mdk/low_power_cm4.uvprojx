# Keil uVision project low_power_cm4.uvprojx, settings and files
target low_power_cm4 debug (ARM-ADS)
  device: LPC54114J256BD64:cm4 NXP
  pack: Keil.LPC54000_DFP.1.2.0
  cpu: CPUTYPE("Cortex-M4") FPU2
  output: low_power_cm4.out
  c flags: Optim=2 OneElfS=1 v6Lang=3 wLevel=3
  c define: DEBUG, CORE1_IMAGE_COPY_TO_RAM, CPU_LPC54114J256BD64_cm4
  c misc: -Wno-typedef-redefinition  -fno-common  -fdata-sections  -ffreestanding  -fno-builtin  -mthumb
  c include: .;sensors
  asm define: CPU_LPC54114J256_M4, DEBUG, KEIL, DEBUG
  asm include: ../../cm0plus/mdk/debug
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x20020000 size 0x8000
  scatter file: LPC54114J256_cm4.scf
  link misc: --remove --keep=*(*core1_code) --keep=*(.crp)
  group source
    ./: low_power_core0.c static_queue.c static_queue.h low_power.h
  group sensors
    sensors/: bma2x2.h bmi160.h bmm050.h bmp280.h
  group board
    ./: pin_mux.c pin_mux.h board.c board.h clock_config.c clock_config.h
  group doc
    ./: readme.txt
target low_power_cm4 release (ARM-ADS)
  device: LPC54114J256BD64:cm4 NXP
  pack: Keil.LPC54000_DFP.1.2.0
  cpu: CPUTYPE("Cortex-M4") FPU2
  output: low_power_cm4.out
  c flags: Optim=7 OneElfS=1 v6Lang=3 wLevel=3
  c define: NDEBUG, CORE1_IMAGE_COPY_TO_RAM, CPU_LPC54114J256BD64_cm4
  c misc: as above
  c include: .;sensors
  asm define: CPU_LPC54114J256_M4, NDEBUG, KEIL, NDEBUG
  asm include: ../../cm0plus/mdk/release
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x20020000 size 0x8000
  scatter file: LPC54114J256_cm4.scf
  link misc: --remove --keep=*(*core1_code) --keep=*(.crp)
software components: Device:SDK Drivers:i2c 2.1.0, Device:SDK Drivers:mailbox 2.0.0, Device:SDK Utilities:debug_console_lite 1.0.0, Device:SDK Utilities:assert_lite 1.0.0, Device:SDK Utilities:incbin 1.0.0, Device:SDK Drivers:common 2.2.9, Device:SDK Drivers:clock 2.2.0, Device:SDK Drivers:power 2.0.0, Device:SDK Drivers:reset 2.0.1, Device:CMSIS:LPC54114_header 1.0.0, CMSIS:CORE 5.3.0, Device:Startup 1.1.0, Device:SDK Drivers:usart 2.4.0, Device:SDK Drivers:flexcomm 2.0.2, Device:SDK Drivers:iocon 2.1.2, Device:SDK Drivers:gpio 2.1.7, Device:SDK Drivers:usart_adapter 1.0.0, Device:SDK Drivers:lists 1.0.0, CMSIS:DSP 1.7.0, Device:CMSIS:LPC54114_system 1.0.0

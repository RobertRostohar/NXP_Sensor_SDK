# IAR project low_power_cm4.ewp, settings and files
configuration debug (ARM, debug)
  General.OGChipSelectEditMenu: LPC54114J256_M4 NXP LPC54114J256_M4
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: DEBUG; CORE1_IMAGE_COPY_TO_RAM; CPU_LPC54114J256BD64_cm4
  ICCARM.CCDiagSuppress: Pe301
  ICCARM.IExtraOptions: --diag_suppress Pa082,Pa050
  ICCARM.CCIncludePath2: $PROJ_DIR$; sensors
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.ADefines: DEBUG
  ILINK.IlinkOutputFile: low_power_cm4.out
  ILINK.IlinkKeepSymbols: _low_power_cm0plus_image
  ILINK.IlinkIcfFile: LPC54114J256_cm4.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG; CORE1_IMAGE_COPY_TO_RAM; CPU_LPC54114J256BD64_cm4
  ICCARM.CCOptLevel: 3
  AARM.ADefines: NDEBUG
  group source
    ./: low_power_core0.c static_queue.c static_queue.h low_power.h
  group sensors
    sensors/: bma2x2.h bmi160.h bmm050.h bmp280.h
  group board
    ./: pin_mux.c pin_mux.h board.c board.h clock_config.c clock_config.h
  group doc
    ./: readme.txt

# IAR project low_power_cm0plus.ewp, settings and files
configuration debug (ARM, debug)
  General.OGChipSelectEditMenu: LPC54114J256_M0+ NXP LPC54114J256_M0+
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 35
  General.FPU2: 0
  ICCARM.CCDefines: DEBUG; CPU_LPC54114J256BD64_cm0plus
  ICCARM.CCDiagSuppress: Pe301
  ICCARM.IExtraOptions: --diag_suppress Pa082,Pa050
  ICCARM.CCIncludePath2: $PROJ_DIR$; sensors
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.ADefines: DEBUG; SLAVEBOOT; NO_CRP
  ILINK.IlinkOutputFile: low_power_cm0plus.out
  ILINK.IlinkIcfFile: LPC54114J256_cm0plus.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG; CPU_LPC54114J256BD64_cm0plus
  ICCARM.CCOptLevel: 3
  AARM.ADefines: NDEBUG; SLAVEBOOT; NO_CRP
  group source
    ./: low_power_core1.c static_queue.c static_queue.h low_power.h
  group sensors
    sensors/: bma2x2.c bma2x2.h bmi160.c bmi160.h bmm050.c bmm050.h bmp280.c bmp280.h
  group board
    ./: pin_mux.c pin_mux.h board.c board.h clock_config.c clock_config.h
  group doc
    ./: readme.txt

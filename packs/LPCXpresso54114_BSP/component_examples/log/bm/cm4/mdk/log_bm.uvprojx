# Keil uVision project log_bm.uvprojx, settings and files
target log_bm debug (ARM-ADS)
  device: LPC54114J256BD64:cm4 NXP
  pack: Keil.LPC54000_DFP.1.2.0
  cpu: CPUTYPE("Cortex-M4") FPU2
  output: log_bm.out
  c flags: Optim=2 OneElfS=1 v6Lang=3 wLevel=3
  c define: DEBUG, CPU_LPC54114J256BD64_cm4, DEBUG_CONSOLE_RX_ENABLE=0, SERIAL_PORT_TYPE_UART=1
  c misc: -fno-common  -fdata-sections  -ffreestanding  -fno-builtin  -mthumb
  c include: .;
  asm define: CPU_LPC54114J256_M4, DEBUG, KEIL, DEBUG
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x20020000 size 0x8000
  scatter file: LPC54114J256_cm4.scf
  link misc: --remove --keep=*(.crp)
  group source
    ./: log_main.c
  group board
    ./: pin_mux.c pin_mux.h board.c board.h clock_config.c clock_config.h
  group doc
    ./: readme.txt
target log_bm release (ARM-ADS)
  device: LPC54114J256BD64:cm4 NXP
  pack: Keil.LPC54000_DFP.1.2.0
  cpu: CPUTYPE("Cortex-M4") FPU2
  output: log_bm.out
  c flags: Optim=7 OneElfS=1 v6Lang=3 wLevel=3
  c define: NDEBUG, CPU_LPC54114J256BD64_cm4, DEBUG_CONSOLE_RX_ENABLE=0, SERIAL_PORT_TYPE_UART=1
  c misc: as above
  c include: .;
  asm define: CPU_LPC54114J256_M4, NDEBUG, KEIL, NDEBUG
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x20020000 size 0x8000
  scatter file: LPC54114J256_cm4.scf
  link misc: --remove --keep=*(.crp)
software components: Device:SDK Utilities:shell 1.0.0, Device:SDK Drivers:lists 1.0.0, Device:SDK Drivers:panic 1.0.0, Device:SDK Utilities:serial_manager 1.0.0, Device:SDK Drivers:common 2.2.9, Device:SDK Utilities:serial_manager_uart 1.0.0, Device:SDK Drivers:osa_bm 1.0.0, Device:SDK Drivers:log 1.0.0, Device:SDK Drivers:debugconsole 1.0.0, Device:SDK Drivers:ringbuffer 1.0.0, Device:SDK Drivers:clock 2.2.0, Device:CMSIS:LPC54114_header 1.0.0, CMSIS:CORE 5.3.0, Device:Startup 1.1.0, Device:SDK Drivers:usart 2.4.0, Device:SDK Drivers:flexcomm 2.0.2, Device:SDK Drivers:iocon 2.1.2, Device:SDK Drivers:gpio 2.1.7, Device:SDK Utilities:assert 1.0.0, Device:SDK Utilities:debug_console 1.0.0, Device:SDK Drivers:usart_adapter 1.0.0, Device:SDK Drivers:power 2.0.0, Device:SDK Drivers:reset 2.0.1, CMSIS:DSP 1.7.0, Device:CMSIS:LPC54114_system 1.0.0

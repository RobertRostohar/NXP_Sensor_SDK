# Keil uVision project fxls8974cf_freemaster_demo.uvprojx, settings and files
target fxls8974cf_freemaster_demo debug (6180000::V6.18::ARMCLANG)
  device: MK22FN512VLH12 NXP
  pack: NXP.MK22F51212_DFP.15.0.0
  cpu: CPUTYPE("Cortex-M4") FPU2
  output: fxls8974cf_freemaster_demo.out
  AfterMake: fromelf.exe --output "$L@L.bin" --bincombined "#L"
  c flags: Optim=2 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: DEBUG, CPU_MK22FN512VLH12, FRDM_K22F, FREEDOM, PRINTF_ADVANCED_ENABLE, SERIAL_PORT_TYPE_UART=1, MCUXPRESSO_SDK
  c misc: -fno-common  -fdata-sections  -ffreestanding  -fno-builtin  -mthumb
  c include: ../../../../..;..;../../../../../../../middleware/issdk/drivers/gpio/kinetis;../../../../../../../middleware/issdk/drivers/gpio;../../../../../../../middleware/issdk/drivers/systick;../../../../../../../middleware/issdk/sensors;../../../../../../../middleware/freemaster/src/common;../../../../../../../middleware/freemaster/src/platforms/gen32le;../../../../../../../middleware/freemaster/src/drivers/mcuxsdk/can;../../../../../../../middleware/freemaster/src/drivers/mcuxsdk/serial
  asm define: DEBUG
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  memory RVCT10: RAM 0x1fff0000 size 0x10000
  scatter file: .\RTE\Device\MK22FN512VLH12\MK22FN512xxx12_flash.scf
  link misc: --remove --keep=*(.FlashConfig) --entry=Reset_Handler
  group board
    ../../../../../: frdm_k22f.c frdm_k22f.h frdm_stbi_a8974_shield.h issdk_hal.h
  group source
    ../: fxls8974cf_freemaster_demo.c freemaster_cfg.h
  group doc
    ../: readme.txt
  group gpio_driver
    ../../../../../../../middleware/issdk/drivers/gpio/kinetis/: gpio_driver_irq.c gpio_driver.c gpio_driver.h
    ../../../../../../../middleware/issdk/drivers/gpio/: Driver_GPIO.h
  group utilities
    ../../../../../../../middleware/issdk/drivers/systick/: systick_utils.c systick_utils.h
  group interfaces
    ../../../../../../../middleware/issdk/sensors/: register_io_i2c.c register_io_spi.c sensor_io_spi.c sensor_io_i2c.c register_io_i2c.h register_io_spi.h sensor_io_spi.h sensor_io_i2c.h sensor_drv.h
  group sensors
    ../../../../../../../middleware/issdk/sensors/: fxls8974.h fxls8974_drv.h fxls8974_drv.c
  group freemaster
    ../../../../../../../middleware/freemaster/src/common/: freemaster.h freemaster_appcmd.c freemaster_defcfg.h freemaster_pipes.c freemaster_private.h freemaster_protocol.c freemaster_protocol.h freemaster_rec.c freemaster_rec.h freemaster_scope.c freemaster_tsa.c freemaster_tsa.h freemaster_ures.c freemaster_ures.h freemaster_utils.c freemaster_utils.h freemaster_can.c freemaster_can.h freemaster_sha.c freemaster_pdbdm.c freemaster_serial.c freemaster_serial.h freemaster_net.c freemaster_net.h
  group freemaster/platforms
    ../../../../../../../middleware/freemaster/src/platforms/gen32le/: freemaster_gen32le.h
  group freemaster/drivers
    ../../../../../../../middleware/freemaster/src/drivers/mcuxsdk/can/: freemaster_flexcan.c freemaster_flexcan.h freemaster_mscan.c freemaster_mscan.h freemaster_mcan.c freemaster_mcan.h
    ../../../../../../../middleware/freemaster/src/drivers/mcuxsdk/serial/: freemaster_serial_uart.c freemaster_serial_uart.h freemaster_serial_lpsci.c freemaster_serial_lpsci.h freemaster_serial_lpuart.c freemaster_serial_lpuart.h freemaster_serial_usart.c freemaster_serial_usart.h freemaster_serial_miniusart.c freemaster_serial_miniusart.h freemaster_serial_usb.c freemaster_serial_usb.h
    ../../../../../../../middleware/freemaster/src/drivers/mcuxsdk/network/: freemaster_net_segger_rtt.c freemaster_net_segger_rtt.h freemaster_net_lwip_udp.c freemaster_net_lwip_udp.h freemaster_net_lwip_tcp.c freemaster_net_lwip_tcp.h
target fxls8974cf_freemaster_demo release (6180000::V6.18::ARMCLANG)
  device: MK22FN512VLH12 NXP
  pack: NXP.MK22F51212_DFP.15.0.0
  cpu: CPUTYPE("Cortex-M4") FPU2
  output: fxls8974cf_freemaster_demo.out
  AfterMake: fromelf.exe --output "$L@L.bin" --bincombined "#L"
  c flags: Optim=7 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: NDEBUG, CPU_MK22FN512VLH12, FRDM_K22F, FREEDOM, PRINTF_ADVANCED_ENABLE, SERIAL_PORT_TYPE_UART=1, MCUXPRESSO_SDK
  c misc: as above
  c include: as above
  asm define: NDEBUG
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  memory RVCT10: RAM 0x1fff0000 size 0x10000
  scatter file: .\RTE\Device\MK22FN512VLH12\MK22FN512xxx12_flash.scf
  link misc: --remove --keep=*(.FlashConfig) --entry=Reset_Handler
software components: CMSIS Driver:I2C:Custom 1.0.0, CMSIS Driver:SPI:Custom 1.0.0, CMSIS Driver:USART:Custom 1.0.0, CMSIS:CORE 5.6.0, Board Support:SDK Project Template:project_template 1.0.0, CMSIS Driver:I2C:i2c_cmsis 2.2.0, CMSIS Driver:SPI:dspi_cmsis 2.3.0, CMSIS Driver:USART:uart_cmsis 2.1.0, Device:CMSIS:MK22F51212_header 1.0.0, Device:CMSIS:MK22F51212_system 1.0.0, Device:SDK Drivers:adc 2.3.0, Device:SDK Drivers:clock 2.3.0, Device:SDK Drivers:common 2.3.2, Device:SDK Drivers:dmamux 2.0.5, Device:SDK Drivers:dspi 2.2.4, Device:SDK Drivers:dspi_edma 2.2.4, Device:SDK Drivers:edma 2.4.3, Device:SDK Drivers:flash 3.0.0, Device:SDK Drivers:gpio 2.6.0, Device:SDK Drivers:i2c 2.0.9, Device:SDK Drivers:i2c_edma 2.0.9, Device:SDK Drivers:lists 1.0.0, Device:SDK Drivers:lptmr 2.1.1, Device:SDK Drivers:lpuart 2.5.3, Device:SDK Drivers:port 2.3.0, Device:SDK Drivers:rtc 2.2.1, Device:SDK Drivers:smc 2.0.7, Device:SDK Drivers:uart 2.5.1, Device:SDK Drivers:uart_adapter 1.0.0, Device:SDK Drivers:uart_edma 2.5.3, Device:SDK Project Template:RTE_Device 1.0.0, Device:SDK Utilities:assert 1.0.0, Device:SDK Utilities:debug_console 1.0.1, Device:SDK Utilities:serial_manager 1.0.1, Device:SDK Utilities:serial_manager_uart 1.0.0, Device:Startup 1.1.0
